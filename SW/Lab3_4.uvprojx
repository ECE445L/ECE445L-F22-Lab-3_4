# Keil uVision project Lab3_4.uvprojx, settings and files
target Lab 3_4 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3_4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group doc
    ./: README.md
  group src
    ./: Lab3_4.c
  group inc
    ./inc/: startup.s PLL.c Timer0A.c Timer2A.c Timer1A.c Timer3A.c Timer4A.c Unified_Port_Init.c UART.c TExaS.c LED.c LaunchPad.c ST7735.c ADCSWTrigger.c PortF.c
    ./: Blynk.c esp8266.c
    ./lib/RGB/: RGB.c
